options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: import_output_paths
  id: import
  parameters:
    imports: import os
  states: {}
- name: N_long_integration
  id: variable
  parameters:
    value: int(short_long_time_scale*(integration_time1*samp_rate/vec_length/min_integration))
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1419e6
  states: {}
- name: integration_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: qtgui_tab_widget_0@0
    label: Integration Time
    label0: Short Integration
    label1: Long Integration
    num_opts: '2'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: integration_time1
  id: variable
  parameters:
    value: '.4'
  states: {}
- name: integration_time2
  id: variable
  parameters:
    value: '10'
  states: {}
- name: min_integration
  id: variable
  parameters:
    comment: |-
      At least integrate 16 times, ~6milliseconds 
      Keep this for normailzation
    value: '16'
  states: {}
- name: prefix_hornA
  id: variable
  parameters:
    value: os.path.join(os.path.expanduser(os.environ.get("DSPIRA_OUTPUT_DIR", "~")), "hornA_")
  states: {}
- name: prefix_hornB
  id: variable
  parameters:
    value: os.path.join(os.path.expanduser(os.environ.get("DSPIRA_OUTPUT_DIR", "~")), "hornB_")
  states: {}
- name: prefix_mag
  id: variable
  parameters:
    value: os.path.join(os.path.expanduser(os.environ.get("DSPIRA_OUTPUT_DIR", "~")), "magnitude_")
  states: {}
- name: prefix_phase
  id: variable
  parameters:
    value: os.path.join(os.path.expanduser(os.environ.get("DSPIRA_OUTPUT_DIR", "~")), "phase_")
  states: {}
- name: reset_integration_button
  id: variable_qtgui_push_button
  parameters:
    gui_hint: qtgui_tab_widget_0@0
    label: Integration Reset
    pressed: '1'
    released: '0'
    type: real
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: save_toggle_csv
  id: variable_qtgui_chooser
  parameters:
    gui_hint: qtgui_tab_widget_0@0
    label: Write to csv files
    label0: Not writing to file
    label1: Writing to file
    num_opts: '2'
    option0: '"False"'
    option1: '"True"'
    type: string
    value: '"False"'
    widget: radio_buttons
  states: {}
- name: short_long_time_scale
  id: variable
  parameters:
    value: int((integration_time2*samp_rate/vec_length/min_integration)/(integration_time1*samp_rate/vec_length/min_integration))
  states: {}
- name: vec_length
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_complex_to_real_1_0
  id: blocks_complex_to_real
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: min_integration
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: min_integration
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0_0_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: min_integration
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0_0_0_1
  id: blocks_integrate_xx
  parameters:
    decim: int(integration_time1*samp_rate/vec_length/min_integration)
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0_0_0_1_0
  id: blocks_integrate_xx
  parameters:
    decim: int(integration_time1*samp_rate/vec_length/min_integration)
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0_0_0_1_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(integration_time1*samp_rate/vec_length/min_integration)
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vec_length)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: vec_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vec_length)
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 16e6
    analog_bandw_ch1: 16e6
    calibr_bandw_ch0: samp_rate
    calibr_bandw_ch1: samp_rate
    ch_align: 'False'
    channel_mode: '2'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '45'
    gain_dB_ch1: '45'
    lna_path_ch0: '3'
    lna_path_ch1: '3'
    oversample: '0'
    rf_freq: center_freq
    samp_rate: samp_rate
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: DATA FILE PATHNAMES
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Interference Spectrometer
    label1: Individual Spectra
    num_tabs: '2'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.05'
    gui_hint: qtgui_tab_widget_0@0
    label1: '"Magnitude"'
    name: '"Correlation Magnitude"'
    vlen: vec_length
    width1: '2'
    x_axis_label: '"Frequency"'
    x_start: (center_freq - samp_rate/2)/1e6
    x_step: (samp_rate/vec_length)/1e6
    x_units: '"MHz"'
    y_axis_label: '"Magnitude"'
    ymax: '250'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.05'
    color1: '"red"'
    gui_hint: qtgui_tab_widget_0@0
    label1: '"Phase"'
    name: '"Correlation Phase"'
    vlen: vec_length
    width1: '2'
    x_axis_label: '"Frequency"'
    x_start: (center_freq - samp_rate/2)/1e6
    x_step: (samp_rate/vec_length)/1e6
    x_units: '"MHz"'
    y_axis_label: '"Phase"'
    ymax: '4'
    ymin: '-1'
  states: {}
- name: qtgui_vector_sink_f_0_1
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.05'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@1
    label1: '"Magnitude"'
    name: '"Horn A"'
    vlen: vec_length
    width1: '2'
    x_axis_label: '"Frequency"'
    x_start: (center_freq - samp_rate/2)/1e6
    x_step: (samp_rate/vec_length)/1e6
    x_units: '"MHz"'
    y_axis_label: '"Signal"'
    ymax: '2000'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_1_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.05'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@1
    label1: '"Magnitude"'
    name: '"Horn B"'
    vlen: vec_length
    width1: '2'
    x_axis_label: '"Frequency"'
    x_start: (center_freq - samp_rate/2)/1e6
    x_step: (samp_rate/vec_length)/1e6
    x_units: '"MHz"'
    y_axis_label: '"Signal"'
    ymax: '10000'
    ymin: '0'
  states: {}
- name: radio_astro_csv_filesink_0
  id: radio_astro_csv_filesink
  parameters:
    az: '""'
    elev: '""'
    freq: center_freq
    integration_select: integration_select
    location: '""'
    prefix: prefix_mag
    samp_rate: samp_rate
    save_toggle: save_toggle_csv
    short_long_time_scale: short_long_time_scale
    vec_length: vec_length
  states: {}
- name: radio_astro_csv_filesink_0_0
  id: radio_astro_csv_filesink
  parameters:
    az: '""'
    elev: '""'
    freq: center_freq
    integration_select: integration_select
    location: '""'
    prefix: prefix_phase
    samp_rate: samp_rate
    save_toggle: save_toggle_csv
    short_long_time_scale: short_long_time_scale
    vec_length: vec_length
  states: {}
- name: radio_astro_csv_filesink_0_1
  id: radio_astro_csv_filesink
  parameters:
    az: '""'
    elev: '""'
    freq: center_freq
    integration_select: integration_select
    location: '""'
    prefix: prefix_hornA
    samp_rate: samp_rate
    save_toggle: save_toggle_csv
    short_long_time_scale: short_long_time_scale
    vec_length: vec_length
  states: {}
- name: radio_astro_csv_filesink_0_1_0
  id: radio_astro_csv_filesink
  parameters:
    az: '""'
    elev: '""'
    freq: center_freq
    integration_select: integration_select
    location: '""'
    prefix: prefix_hornB
    samp_rate: samp_rate
    save_toggle: save_toggle_csv
    short_long_time_scale: short_long_time_scale
    vec_length: vec_length
  states: {}
- name: radio_astro_vector_moving_average_0
  id: radio_astro_vector_moving_average
  parameters:
    averaging_length: short_long_time_scale
    intype: complex
    reset_integration: reset_integration_button
    vec_length: vec_length
  states: {}
- name: radio_astro_vector_moving_average_0_0
  id: radio_astro_vector_moving_average
  parameters:
    averaging_length: short_long_time_scale
    intype: complex
    reset_integration: reset_integration_button
    vec_length: vec_length
  states: {}
- name: radio_astro_vector_moving_average_0_0_0
  id: radio_astro_vector_moving_average
  parameters:
    averaging_length: short_long_time_scale
    intype: complex
    reset_integration: reset_integration_button
    vec_length: vec_length
  states: {}

connections:
- [blocks_complex_to_magphase_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_complex_to_magphase_0, '0', radio_astro_csv_filesink_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_vector_sink_f_0_0, '0']
- [blocks_complex_to_magphase_0, '1', radio_astro_csv_filesink_0_0, '0']
- [blocks_complex_to_real_1, '0', qtgui_vector_sink_f_0_1, '0']
- [blocks_complex_to_real_1, '0', radio_astro_csv_filesink_0_1, '0']
- [blocks_complex_to_real_1_0, '0', qtgui_vector_sink_f_0_1_0, '0']
- [blocks_complex_to_real_1_0, '0', radio_astro_csv_filesink_0_1_0, '0']
- [blocks_integrate_xx_0_0_0, '0', blocks_integrate_xx_0_0_0_1, '0']
- [blocks_integrate_xx_0_0_0_0, '0', blocks_integrate_xx_0_0_0_1_0, '0']
- [blocks_integrate_xx_0_0_0_0_0, '0', blocks_integrate_xx_0_0_0_1_0_0, '0']
- [blocks_integrate_xx_0_0_0_1, '0', radio_astro_vector_moving_average_0, '0']
- [blocks_integrate_xx_0_0_0_1_0, '0', radio_astro_vector_moving_average_0_0, '0']
- [blocks_integrate_xx_0_0_0_1_0_0, '0', radio_astro_vector_moving_average_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_integrate_xx_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_integrate_xx_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0_0, '0', blocks_integrate_xx_0_0_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0_0_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0_0_0, '1']
- [limesdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [limesdr_source_0, '1', blocks_stream_to_vector_0_0, '0']
- [radio_astro_vector_moving_average_0, '0', blocks_complex_to_magphase_0, '0']
- [radio_astro_vector_moving_average_0_0, '0', blocks_complex_to_real_1, '0']
- [radio_astro_vector_moving_average_0_0_0, '0', blocks_complex_to_real_1_0, '0']

metadata:
  file_format: 1
