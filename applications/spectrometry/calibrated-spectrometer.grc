options:
  parameters:
    author: DSPIRA
    generate_options: qt_gui
    id: DSPIRA_Spectrometer
    output_language: python
    title: DSPIRA Spectrometer
  states: {}

blocks:
- name: import_output_paths
  id: import
  parameters:
    imports: import os
  states: {}
- name: N_long_integration
  id: variable
  parameters:
    value: int(short_long_time_scale*(integration_time1*samp_rate/vec_length/min_integration))
  states: {}
- name: az
  id: variable_qtgui_entry
  parameters:
    gui_hint: qtgui_tab_widget_0@0:[2,0,1,2]
    label: azimuth (hit 'Enter' after typing)
    type: string
    value: '0'
  states: {}
- name: clip_toggle
  id: variable_qtgui_chooser
  parameters:
    gui_hint: qtgui_tab_widget_0@0:[0,4,1,1]
    label: Full or Clipped Spectrum
    label0: Clipped spectrum
    label1: Full spectrum
    num_opts: '2'
    option0: '"True"'
    option1: '"False"'
    type: string
    value: '"True"'
    widget: radio_buttons
  states: {}
- name: collect
  id: variable_qtgui_chooser
  parameters:
    gui_hint: qtgui_tab_widget_0@0:[0,1,1,1]
    label: '"Spectrum Display"'
    label0: '"Filtered spectrum with no calibration"'
    label1: '"Spectrum with calibration"'
    label2: '"Hot calibration"'
    label3: '"Cold calibration"'
    label4: '"Unfiltered spectrum with no calibration"'
    num_opts: '5'
    option0: '"nocal"'
    option1: '"cal"'
    option2: '"hot"'
    option3: '"cold"'
    option4: '"nocal_nofilter"'
    type: string
    value: '"nocal"'
    widget: radio_buttons
  states: {}
- name: custom_window
  id: variable
  parameters:
    value: sinc*np.hamming(4*vec_length)
  states: {}
- name: elev
  id: variable_qtgui_entry
  parameters:
    gui_hint: qtgui_tab_widget_0@0:[3,0,1,2]
    label: elevation (hit 'Enter' after typing)
    type: string
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1419e6
  states: {}
- name: freq_start
  id: variable
  parameters:
    value: freq - samp_rate/2
  states: {}
- name: freq_step
  id: variable
  parameters:
    value: samp_rate/vec_length
  states: {}
- name: graphinfo
  id: variable_qtgui_entry
  parameters:
    gui_hint: 'qtgui_tab_widget_0@0 '
    label: Info added to png filename (hit 'Enter' after typing)
    type: string
    value: '""'
  states: {}
- name: graphprint_toggle
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 'qtgui_tab_widget_0@0 '
    label: Print Graph to File
    pressed: '"True"'
    released: '"False"'
    type: string
    value: '"False"'
  states: {}
- name: integration_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: qtgui_tab_widget_0@0:[0,2,1,1]
    label: Integration Time
    label0: Short Integration
    label1: Long Integration
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: integration_time1
  id: variable
  parameters:
    value: '.4'
  states: {}
- name: integration_time2
  id: variable
  parameters:
    value: '10'
  states: {}
- name: location
  id: variable_qtgui_entry
  parameters:
    gui_hint: qtgui_tab_widget_0@0:[2,3,1,4]
    label: location (hit 'Enter' after typing)
    type: string
    value: Anytown
  states: {}
- name: min_integration
  id: variable
  parameters:
    comment: |-
      At least integrate 16 times, ~6milliseconds 
      Keep this for normailzation
    value: '16'
  states: {}
- name: prefix
  id: variable
  parameters:
    value: os.path.join(os.path.expanduser(os.environ.get("DSPIRA_OUTPUT_DIR", "~")), "spectrum_")
  states: {}
- name: rectfile
  id: variable
  parameters:
    value: prefix + timenow + ".h5"
  states: {}
- name: reset_integration_button
  id: variable_qtgui_push_button
  parameters:
    gui_hint: qtgui_tab_widget_0@0:[1,2,1,1]
    label: Integration Reset
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: save_toggle_csv
  id: variable_qtgui_chooser
  parameters:
    gui_hint: qtgui_tab_widget_0@0:[0,6,1,1]
    label: Write to csv files
    label0: Not writing to file
    label1: Writing to file
    num_opts: '2'
    option0: '"False"'
    option1: '"True"'
    type: string
    value: '"False"'
    widget: radio_buttons
  states: {}
- name: short_long_time_scale
  id: variable
  parameters:
    value: int((integration_time2*samp_rate/vec_length/min_integration)/(integration_time1*samp_rate/vec_length/min_integration))
  states: {}
- name: sinc
  id: variable
  parameters:
    value: np.sinc(sinc_sample_locations/np.pi)
  states: {}
- name: sinc_sample_locations
  id: variable
  parameters:
    value: np.arange(-np.pi*4/2.0, np.pi*4/2.0, np.pi/vec_length)
  states: {}
- name: spectrumcapture_toggle
  id: variable_qtgui_push_button
  parameters:
    gui_hint: qtgui_tab_widget_0@0:[1,4,1,3]
    label: Capture Current Spectrum
    pressed: 'True'
    released: 'False'
    type: string
    value: 'False'
  states: {}
- name: timenow
  id: variable
  parameters:
    value: datetime.now().strftime("%Y-%m-%d_%H.%M.%S")
  states: {}
- name: vec_length
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: ymax
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@0:[1,0,1,1]
    label: y-axis max
    min_len: '5'
    start: '0'
    step: '10'
    stop: '10000'
    value: '200'
  states: {}
- name: ymin
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@0 :[0,0,1,1]
    label: y-axis min
    min_len: '5'
    start: '-200'
    step: '10'
    stop: '1000'
    value: '0'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: vec_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: 2*vec_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: 3*vec_length
    type: complex
  states: {}
- name: blocks_integrate_xx_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: min_integration
    type: float
    vlen: vec_length
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[-vec_length:]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[2*vec_length:3*vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[1*vec_length:2*vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[0:vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: integration_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
    vlen: vec_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(vec_length)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Check/change these variables
      before each run.
    note: USER DEFINED VARIABLES
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Polyphase Functions
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Graph Options
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: airspy=0,bias=1,pack=0
    bb_gain0: '0'
    freq0: freq
    gain0: '21'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    gui_hint: qtgui_tab_widget_0@0:[0,8,3,1]
    label1: Histogram
    name: '"System Heartbeat"'
    size: '1024'
    type: float
    update_time: '1'
    xmax: '.5'
    xmin: '-.5'
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Spectrum
    label1: System Temp/Gain
    num_tabs: '2'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@1
    label1: Gain
    name: '"Gain"'
    vlen: vec_length
    width1: '3'
    x_axis_label: '"Frequency (MHz)"'
    x_start: (freq - samp_rate/2)/1e6
    x_step: (samp_rate/vec_length)/1e6
    x_units: '"MHz"'
    y_axis_label: '"Gain"'
    ymax: '5'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@1
    label1: Temp
    name: '"System Temperature"'
    vlen: vec_length
    width1: '3'
    x_axis_label: '"Frequency (MHz)"'
    x_start: (freq - samp_rate/2)/1e6
    x_step: (samp_rate/vec_length)/1e6
    x_units: '"MHz"'
    y_axis_label: '"System Temperature (K)"'
    y_units: '"K"'
    ymax: '400'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_0_1
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0:[4,0,20,10]
    label1: Spectrum
    name: '"Spectrum"'
    vlen: vec_length
    width1: '2'
    x_axis_label: '"Frequency (MHz)"'
    x_start: (freq - samp_rate/2)/1e6
    x_step: (samp_rate/vec_length)/1e6
    x_units: '"MHz"'
    y_axis_label: '"Signal"'
    ymax: ymax
    ymin: ymin
  states: {}
- name: radio_astro_csv_filesink_0
  id: radio_astro_csv_filesink
  parameters:
    az: az
    elev: elev
    freq: freq
    integration_select: integration_select
    location: location
    prefix: prefix
    samp_rate: samp_rate
    save_toggle: save_toggle_csv
    short_long_time_scale: short_long_time_scale
    vec_length: vec_length
  states: {}
- name: radio_astro_integration_0
  id: radio_astro_integration
  parameters:
    n_integrations: int(integration_time1*samp_rate/vec_length/min_integration)
    vec_length: vec_length
  states: {}
- name: radio_astro_png_print_spectrum_0
  id: radio_astro_png_print_spectrum
  parameters:
    freq: freq
    graphinfo: graphinfo
    graphprint_toggle: graphprint_toggle
    prefix: prefix
    samp_rate: samp_rate
    vec_length: vec_length
  states: {}
- name: radio_astro_systemp_calibration_0
  id: radio_astro_systemp_calibration
  parameters:
    az: az
    clip_toggle: clip_toggle
    collect: collect
    elev: elev
    freq: freq
    location: location
    prefix: prefix
    samp_rate: samp_rate
    spectrumcapture_toggle: spectrumcapture_toggle
    vec_length: vec_length
  states: {}
- name: radio_astro_vector_moving_average_0
  id: radio_astro_vector_moving_average
  parameters:
    averaging_length: short_long_time_scale
    intype: float
    reset_integration: reset_integration_button
    vec_length: vec_length
  states: {}

connections:
- [blocks_add_xx_0, '0', fft_vxx_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_complex_to_real_1, '0', blocks_integrate_xx_0_0_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [blocks_integrate_xx_0_0_0, '0', radio_astro_integration_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_real_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_selector_0, '0', radio_astro_systemp_calibration_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [osmosdr_source_0, '0', blocks_complex_to_real_0, '0']
- [osmosdr_source_0, '0', blocks_delay_0, '0']
- [osmosdr_source_0, '0', blocks_delay_0_0, '0']
- [osmosdr_source_0, '0', blocks_delay_0_0_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [radio_astro_integration_0, '0', blocks_selector_0, '0']
- [radio_astro_integration_0, '0', radio_astro_vector_moving_average_0, '0']
- [radio_astro_systemp_calibration_0, '0', qtgui_vector_sink_f_0_0_1, '0']
- [radio_astro_systemp_calibration_0, '0', radio_astro_csv_filesink_0, '0']
- [radio_astro_systemp_calibration_0, '0', radio_astro_png_print_spectrum_0, '0']
- [radio_astro_systemp_calibration_0, '1', qtgui_vector_sink_f_0_0, '0']
- [radio_astro_systemp_calibration_0, '2', qtgui_vector_sink_f_0_0_0, '0']
- [radio_astro_vector_moving_average_0, '0', blocks_selector_0, '1']

metadata:
  file_format: 1
